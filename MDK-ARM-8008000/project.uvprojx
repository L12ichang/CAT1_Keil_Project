# Keil uVision project project.uvprojx, settings and files
target program (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: cat1 +hex
  AfterMake: .\out\hex2bin_arm.bat
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB,APROM_OFFSET
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\Core\Src;..\Core\Src\LampProtocolLib;..\Core\Src\gateway;..\Core\Src\CJSON
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x1c000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_ll_usb.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_flash.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group system
    ../Core/Src/: sys_tick.c mylib.c buzzer.c build_date.c sys_dim_voltage_out.c u32_q.c sys_serial_port.c crc16_ccitt.c crc16_modbus.c standby_mode.c for_iap.c watchdog.c sys_bl0942.c sys_data.c sys_temp_over_protect.c sys_pwm.c sys_aip1302.c sys_pow_drop_check.c danger_current_check.c sys_Vo_Io.c factory_user_data.c data_backup.c
  group hardware
    ../Core/Src/: hw_tim4_pwm2.c hw_uart3.c hw_tim2.c hw_tim3_pwm2.c hw_tim4_cap1.c hw_flash.c charge.c hw_uart2.c hw_tim1_pwm2.c hw_uart1.c adc.c dma.c ntc.c oco.c hw_4g_io.c aip1302.c
  group application
    ../Core/Src/: offline_Time_controlled_dimming.c
  group gateway
    ../Core/Src/LampProtocolLib/: App.c
    ../Core/Src/gateway/: net_dim.c
  group login
    ../Core/Src/LampProtocolLib/: Protocol.c NbDriver.c TcpClient.c Queue.c Utils.c SystemConfig.c Portable.c ota.c hw_gateway.c Json_Protocol.c mqtt_zk_protocol.c zk_alarm.c zk_runtime_stats.c zk_property.c zk_work_plan.c zk_sunriset.c
    ../Core/Src/CJSON/: cJSON.c
software components: CMSIS:CORE 5.6.0
